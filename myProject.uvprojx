# Keil uVision project myProject.uvprojx, settings and files
target default (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myProject
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ./: main.c delay.c delay.h ITM_Retarget.c ring_buffer.c ring_buffer.h ring_buffer_unit_test.c ring_buffer_unit_test.h core.c core.h usart.c usart.h
software components: CMSIS:CORE 5.1.1, Device:STM32Cube Framework:Classic 1.7.3, Device:STM32Cube HAL:Common 1.7.3, Device:STM32Cube HAL:Cortex 1.7.3, Device:STM32Cube HAL:GPIO 1.7.3, Device:STM32Cube HAL:PWR 1.7.3, Device:STM32Cube HAL:RCC 1.7.3, Device:Startup 2.6.2
